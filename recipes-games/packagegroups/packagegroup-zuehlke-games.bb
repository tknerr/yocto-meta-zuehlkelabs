inherit packagegroup

SUMMARY = "Collection of custom games"
DESCRIPTION = "Collection of custom games to be added as a packagegroup"

RDEPENDS_${PN} = "\
    ninvaders \
    "
